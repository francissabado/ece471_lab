* # FILE NAME: /NFS/STAK/STUDENTS/B/BRANAUGJ/CADENCE/SIMULATION/NOR2/
* HSPICES/SCHEMATIC/NETLIST/NOR2.C.RAW
* NETLIST OUTPUT FOR HSPICES.
* GENERATED ON FEB 3 16:22:30 2014

* FILE NAME: ECE471_LIB_NOR2_SCHEMATIC.S.
* SUBCIRCUIT FOR CELL: NOR2.
* GENERATED FOR: HSPICES.
* GENERATED ON FEB  3 16:22:30 2014.

VN2 NET6 IN_B 0
VN1 NET8 IN_A 0
VP2 NET10 IN_B 0
VP1 NET12 IN_A 0
MP3 NET19 OUT VDD! VDD!  TSMC25DP  L=264E-9 W=960E-9 AD=576E-15 AS=576E-15
+PD=3.12E-6 PS=3.12E-6 M=1
MP2 NET34 OUT NET19 NET19  TSMC25DP  L=264E-9 W=960E-9 AD=576E-15 AS=576E-15
+PD=3.12E-6 PS=3.12E-6 M=1
MP1 NET27 NET12 VDD! VDD!  TSMC25DP  L=264E-9 W=960E-9 AD=576E-15 AS=576E-15
+PD=3.12E-6 PS=3.12E-6 M=1
MP0 OUT NET10 NET27 NET27  TSMC25DP  L=264E-9 W=960E-9 AD=576E-15 AS=576E-15
+PD=3.12E-6 PS=3.12E-6 M=1
MN3 NET34 OUT GND! GND!  TSMC25DN  L=264E-9 W=480E-9 AD=288E-15 AS=288E-15
+PD=2.16E-6 PS=2.16E-6 M=1
MN2 NET34 OUT GND! GND!  TSMC25DN  L=264E-9 W=480E-9 AD=288E-15 AS=288E-15
+PD=2.16E-6 PS=2.16E-6 M=1
MN0 OUT NET8 GND! GND!  TSMC25DN  L=264E-9 W=480E-9 AD=288E-15 AS=288E-15
+PD=2.16E-6 PS=2.16E-6 M=1
MN1 OUT NET6 GND! GND!  TSMC25DN  L=264E-9 W=480E-9 AD=288E-15 AS=288E-15
+PD=2.16E-6 PS=2.16E-6 M=1
