* # FILE NAME: /NFS/STAK/STUDENTS/B/BRANAUGJ/CADENCE/SIMULATION/NOR2/
* HSPICES/SCHEMATIC/NETLIST/NOR2.C.RAW
* NETLIST OUTPUT FOR HSPICES.
* GENERATED ON FEB 3 16:22:30 2014

* FILE NAME: ECE471_LIB_NOR2_SCHEMATIC.S.
* SUBCIRCUIT FOR CELL: NOR2.
* GENERATED FOR: HSPICES.
* GENERATED ON FEB  3 16:22:30 2014.

VN2 NET6 IN_B 0
VN1 NET8 IN_A 0
VP2 NET10 IN_B 0
VP1 NET12 IN_A 0
MP3 NET19 OUT VDD! VDD!  pmos  L=3.52e-08 W=1.28e-07 AD=1.024e-14 AS=1.024e-14
+PD=2.88e-07 PS=2.88e-07 M=1
MP2 NET34 OUT NET19 NET19  pmos  L=3.52e-08 W=1.28e-07 AD=1.024e-14 AS=1.024e-14
+PD=2.88e-07 PS=2.88e-07 M=1
MP1 NET27 NET12 VDD! VDD!  pmos  L=3.52e-08 W=1.28e-07 AD=1.024e-14 AS=1.024e-14
+PD=2.88e-07 PS=2.88e-07 M=1
MP0 OUT NET10 NET27 NET27  pmos  L=3.52e-08 W=1.28e-07 AD=1.024e-14 AS=1.024e-14
+PD=2.88e-07 PS=2.88e-07 M=1
MN3 NET34 OUT GND! GND!  nmos  L=3.52e-08 W=6.4e-08 AD=5.12e-15 AS=5.12e-15
+PD=2.24e-07 PS=2.24e-07 M=1
MN2 NET34 OUT GND! GND!  nmos  L=3.52e-08 W=6.4e-08 AD=5.12e-15 AS=5.12e-15
+PD=2.24e-07 PS=2.24e-07 M=1
MN0 OUT NET8 GND! GND!  nmos  L=3.52e-08 W=6.4e-08 AD=5.12e-15 AS=5.12e-15
+PD=2.24e-07 PS=2.24e-07 M=1
MN1 OUT NET6 GND! GND!  nmos  L=3.52e-08 W=6.4e-08 AD=5.12e-15 AS=5.12e-15
+PD=2.24e-07 PS=2.24e-07 M=1
