* # FILE NAME: /NFS/STAK/STUDENTS/B/BRANAUGJ/CADENCE/SIMULATION/FINAL/
* HSPICES/SCHEMATIC/NETLIST/FINAL.C.RAW
* NETLIST OUTPUT FOR HSPICES.
* GENERATED ON MAR 15 19:21:34 2014

* GLOBAL NET DEFINITIONS
.GLOBAL VDD!
* FILE NAME: ECE471_LIB_FINAL_SCHEMATIC.S.
* SUBCIRCUIT FOR CELL: FINAL.
* GENERATED FOR: HSPICES.
* GENERATED ON MAR 15 19:21:34 2014.

C97 WL1 0  23.7E-15 M=1.0
C96 NET335 0  23.7E-15 M=1.0
C95 NET338 0  15.8E-15 M=1.0
C94 RD0 0  15.8E-15 M=1.0
C93 NET440 0  15.8E-15 M=1.0
C92 NET340 0  15.8E-15 M=1.0
C91 NET342 0  15.8E-15 M=1.0
C90 NET438 0  15.8E-15 M=1.0
C89 RD1 0  15.8E-15 M=1.0
C88 NET344 0  15.8E-15 M=1.0
C87 NET346 0  15.8E-15 M=1.0
C86 RD2 0  15.8E-15 M=1.0
C85 NET442 0  15.8E-15 M=1.0
C84 NET348 0  15.8E-15 M=1.0
C83 NET350 0  15.8E-15 M=1.0
C82 NET462 0  15.8E-15 M=1.0
C81 RD3 0  15.8E-15 M=1.0
C80 NET352 0  15.8E-15 M=1.0
C79 NET354 0  15.8E-15 M=1.0
C78 RD4 0  15.8E-15 M=1.0
C77 NET446 0  15.8E-15 M=1.0
C76 NET356 0  15.8E-15 M=1.0
C75 NET358 0  15.8E-15 M=1.0
C74 NET444 0  15.8E-15 M=1.0
C73 RD5 0  15.8E-15 M=1.0
C72 NET360 0  15.8E-15 M=1.0
C71 NET362 0  15.8E-15 M=1.0
C70 RD6 0  15.8E-15 M=1.0
C69 NET434 0  15.8E-15 M=1.0
C68 NET364 0  15.8E-15 M=1.0
C67 NET366 0  15.8E-15 M=1.0
C66 NET436 0  15.8E-15 M=1.0
C65 RD7 0  15.8E-15 M=1.0
C64 NET368 0  15.8E-15 M=1.0
C63 NET370 0  15.8E-15 M=1.0
C62 RD8 0  15.8E-15 M=1.0
C61 NET432 0  15.8E-15 M=1.0
C60 NET372 0  15.8E-15 M=1.0
C59 NET374 0  15.8E-15 M=1.0
C58 NET450 0  15.8E-15 M=1.0
C57 RD9 0  15.8E-15 M=1.0
C56 NET376 0  15.8E-15 M=1.0
C55 NET378 0  15.8E-15 M=1.0
C54 RD10 0  15.8E-15 M=1.0
C53 NET458 0  15.8E-15 M=1.0
C52 NET380 0  15.8E-15 M=1.0
C51 NET382 0  15.8E-15 M=1.0
C50 NET456 0  15.8E-15 M=1.0
C49 RD11 0  15.8E-15 M=1.0
C48 NET384 0  15.8E-15 M=1.0
C47 NET386 0  15.8E-15 M=1.0
C46 RD12 0  15.8E-15 M=1.0
C45 NET460 0  15.8E-15 M=1.0
C44 NET388 0  15.8E-15 M=1.0
C43 NET390 0  15.8E-15 M=1.0
C42 NET452 0  15.8E-15 M=1.0
C41 RD13 0  15.8E-15 M=1.0
C40 NET392 0  15.8E-15 M=1.0
C39 NET394 0  15.8E-15 M=1.0
C38 RD14 0  15.8E-15 M=1.0
C37 NET454 0  15.8E-15 M=1.0
C36 NET396 0  15.8E-15 M=1.0
C35 NET398 0  15.8E-15 M=1.0
C34 NET448 0  15.8E-15 M=1.0
C31 RD15 0  15.8E-15 M=1.0
C30 NET400 0  15.8E-15 M=1.0
C2 NET401 0  23.7E-15 M=1.0
C3 WL2 0  23.7E-15 M=1.0
C4 WL3 0  23.7E-15 M=1.0
C5 NET403 0  23.7E-15 M=1.0
C1 NET411 0  23.7E-15 M=1.0
C6 NET405 0  23.7E-15 M=1.0
C7 WL4 0  23.7E-15 M=1.0
C8 WL5 0  23.7E-15 M=1.0
C9 NET407 0  23.7E-15 M=1.0
C0 WL0 0  23.7E-15 M=1.0
C10 WL6 0  23.7E-15 M=1.0
C11 NET409 0  23.7E-15 M=1.0
C12 NET413 0  23.7E-15 M=1.0
C13 WL7 0  23.7E-15 M=1.0
C14 WL8 0  23.7E-15 M=1.0
C15 NET415 0  23.7E-15 M=1.0
C16 NET417 0  23.7E-15 M=1.0
C17 WL9 0  23.7E-15 M=1.0
C18 WL10 0  23.7E-15 M=1.0
C19 NET419 0  23.7E-15 M=1.0
C20 NET421 0  23.7E-15 M=1.0
C21 WL11 0  23.7E-15 M=1.0
C22 WL12 0  23.7E-15 M=1.0
C23 NET423 0  23.7E-15 M=1.0
C24 NET425 0  23.7E-15 M=1.0
C25 WL13 0  23.7E-15 M=1.0
C26 WL14 0  23.7E-15 M=1.0
C27 NET427 0  23.7E-15 M=1.0
C28 NET429 0  23.7E-15 M=1.0
C29 WL15 0  23.7E-15 M=1.0
R48 WL1 NET335  72.0 M=1.0
R47 NET338 RD0  48.0 M=1.0
R46 NET340 NET440  48.0 M=1.0
R45 NET342 NET438  48.0 M=1.0
R44 NET344 RD1  48.0 M=1.0
R43 NET346 RD2  48.0 M=1.0
R42 NET348 NET442  48.0 M=1.0
R41 NET350 NET462  48.0 M=1.0
R40 NET352 RD3  48.0 M=1.0
R39 NET354 RD4  48.0 M=1.0
R38 NET356 NET446  48.0 M=1.0
R37 NET358 NET444  48.0 M=1.0
R36 NET360 RD5  48.0 M=1.0
R35 NET362 RD6  48.0 M=1.0
R34 NET364 NET434  48.0 M=1.0
R33 NET366 NET436  48.0 M=1.0
R32 NET368 RD7  48.0 M=1.0
R31 NET370 RD8  48.0 M=1.0
R30 NET372 NET432  48.0 M=1.0
R29 NET374 NET450  48.0 M=1.0
R28 NET376 RD9  48.0 M=1.0
R27 NET378 RD10  48.0 M=1.0
R26 NET380 NET458  48.0 M=1.0
R25 NET382 NET456  48.0 M=1.0
R24 NET384 RD11  48.0 M=1.0
R23 NET386 RD12  48.0 M=1.0
R22 NET388 NET460  48.0 M=1.0
R21 NET390 NET452  48.0 M=1.0
R20 NET392 RD13  48.0 M=1.0
R19 NET394 RD14  48.0 M=1.0
R18 NET396 NET454  48.0 M=1.0
R17 NET398 NET448  48.0 M=1.0
R15 NET400 RD15  48.0 M=1.0
R1 WL2 NET401  72.0 M=1.0
R2 WL3 NET403  72.0 M=1.0
R3 WL4 NET405  72.0 M=1.0
R4 WL5 NET407  72.0 M=1.0
R5 WL6 NET409  72.0 M=1.0
R0 WL0 NET411  72.0 M=1.0
R6 WL7 NET413  72.0 M=1.0
R7 WL8 NET415  72.0 M=1.0
R8 WL9 NET417  72.0 M=1.0
R9 WL10 NET419  72.0 M=1.0
R10 WL11 NET421  72.0 M=1.0
R11 WL12 NET423  72.0 M=1.0
R12 WL13 NET425  72.0 M=1.0
R13 WL14 NET427  72.0 M=1.0
R14 WL15 NET429  72.0 M=1.0
XI297 NET431 NET432 SUB1
XI299 NET433 NET434 SUB1
XI298 NET435 NET436 SUB1
XI304 NET437 NET438 SUB1
XI305 NET439 NET440 SUB1
XI303 NET441 NET442 SUB1
XI300 NET443 NET444 SUB1
XI301 NET445 NET446 SUB1
XI290 NET447 NET448 SUB1
XI296 NET449 NET450 SUB1
XI292 NET451 NET452 SUB1
XI291 NET453 NET454 SUB1
XI294 NET455 NET456 SUB1
XI295 NET457 NET458 SUB1
XI293 NET459 NET460 SUB1
XI302 NET461 NET462 SUB1
XI81 WR11 WR_EN RD11 SUB2
XI80 WR11 WR_EN NET455 SUB2
XI79 WR10 WR_EN NET457 SUB2
XI78 WR10 WR_EN RD10 SUB2
XI77 WR8 WR_EN RD8 SUB2
XI76 WR8 WR_EN NET431 SUB2
XI75 WR9 WR_EN NET449 SUB2
XI74 WR9 WR_EN RD9 SUB2
XI41 WR13 WR_EN RD13 SUB2
XI40 WR13 WR_EN NET451 SUB2
XI39 WR12 WR_EN NET459 SUB2
XI38 WR12 WR_EN RD12 SUB2
XI21 WR14 WR_EN RD14 SUB2
XI20 WR14 WR_EN NET453 SUB2
XI19 WR15 WR_EN NET447 SUB2
XI18 WR15 WR_EN RD15 SUB2
XI161 WR7 WR_EN RD7 SUB2
XI160 WR7 WR_EN NET435 SUB2
XI159 WR6 WR_EN NET433 SUB2
XI158 WR6 WR_EN RD6 SUB2
XI157 WR4 WR_EN RD4 SUB2
XI156 WR4 WR_EN NET445 SUB2
XI155 WR5 WR_EN NET443 SUB2
XI154 WR5 WR_EN RD5 SUB2
XI153 WR1 WR_EN RD1 SUB2
XI152 WR1 WR_EN NET437 SUB2
XI151 WR0 WR_EN NET439 SUB2
XI150 WR0 WR_EN RD0 SUB2
XI149 WR2 WR_EN RD2 SUB2
XI148 WR2 WR_EN NET441 SUB2
XI147 WR3 WR_EN NET461 SUB2
XI146 WR3 WR_EN RD3 SUB2
XI145 NET382 NET384 NET411 FINAL_SRAM_G2
XI144 NET382 NET384 NET335 FINAL_SRAM_G2
XI143 NET382 NET384 NET401 FINAL_SRAM_G2
XI142 NET382 NET384 NET403 FINAL_SRAM_G2
XI141 NET382 NET384 NET405 FINAL_SRAM_G2
XI140 NET382 NET384 NET407 FINAL_SRAM_G2
XI139 NET382 NET384 NET409 FINAL_SRAM_G2
XI138 NET382 NET384 NET413 FINAL_SRAM_G2
XI137 NET382 NET384 NET415 FINAL_SRAM_G2
XI136 NET382 NET384 NET417 FINAL_SRAM_G2
XI135 NET382 NET384 NET419 FINAL_SRAM_G2
XI134 NET382 NET384 NET421 FINAL_SRAM_G2
XI133 NET382 NET384 NET423 FINAL_SRAM_G2
XI132 NET382 NET384 NET425 FINAL_SRAM_G2
XI131 NET382 NET384 NET427 FINAL_SRAM_G2
XI130 NET382 NET384 NET429 FINAL_SRAM_G2
XI129 NET380 NET378 NET429 FINAL_SRAM_G2
XI128 NET380 NET378 NET427 FINAL_SRAM_G2
XI127 NET380 NET378 NET425 FINAL_SRAM_G2
XI126 NET380 NET378 NET423 FINAL_SRAM_G2
XI125 NET380 NET378 NET421 FINAL_SRAM_G2
XI124 NET380 NET378 NET419 FINAL_SRAM_G2
XI123 NET380 NET378 NET417 FINAL_SRAM_G2
XI122 NET380 NET378 NET415 FINAL_SRAM_G2
XI121 NET380 NET378 NET413 FINAL_SRAM_G2
XI120 NET380 NET378 NET409 FINAL_SRAM_G2
XI119 NET380 NET378 NET407 FINAL_SRAM_G2
XI118 NET380 NET378 NET405 FINAL_SRAM_G2
XI117 NET380 NET378 NET403 FINAL_SRAM_G2
XI116 NET380 NET378 NET401 FINAL_SRAM_G2
XI115 NET380 NET378 NET335 FINAL_SRAM_G2
XI114 NET380 NET378 NET411 FINAL_SRAM_G2
XI113 NET372 NET370 NET411 FINAL_SRAM_G2
XI112 NET372 NET370 NET335 FINAL_SRAM_G2
XI111 NET372 NET370 NET401 FINAL_SRAM_G2
XI110 NET372 NET370 NET403 FINAL_SRAM_G2
XI109 NET372 NET370 NET405 FINAL_SRAM_G2
XI108 NET372 NET370 NET407 FINAL_SRAM_G2
XI107 NET372 NET370 NET409 FINAL_SRAM_G2
XI106 NET372 NET370 NET413 FINAL_SRAM_G2
XI105 NET372 NET370 NET415 FINAL_SRAM_G2
XI104 NET372 NET370 NET417 FINAL_SRAM_G2
XI103 NET372 NET370 NET419 FINAL_SRAM_G2
XI102 NET372 NET370 NET421 FINAL_SRAM_G2
XI101 NET372 NET370 NET423 FINAL_SRAM_G2
XI100 NET372 NET370 NET425 FINAL_SRAM_G2
XI99 NET372 NET370 NET427 FINAL_SRAM_G2
XI98 NET372 NET370 NET429 FINAL_SRAM_G2
XI97 NET374 NET376 NET429 FINAL_SRAM_G2
XI96 NET374 NET376 NET427 FINAL_SRAM_G2
XI95 NET374 NET376 NET425 FINAL_SRAM_G2
XI94 NET374 NET376 NET423 FINAL_SRAM_G2
XI93 NET374 NET376 NET421 FINAL_SRAM_G2
XI92 NET374 NET376 NET419 FINAL_SRAM_G2
XI91 NET374 NET376 NET417 FINAL_SRAM_G2
XI90 NET374 NET376 NET415 FINAL_SRAM_G2
XI89 NET374 NET376 NET413 FINAL_SRAM_G2
XI88 NET374 NET376 NET409 FINAL_SRAM_G2
XI87 NET374 NET376 NET407 FINAL_SRAM_G2
XI86 NET374 NET376 NET405 FINAL_SRAM_G2
XI85 NET374 NET376 NET403 FINAL_SRAM_G2
XI84 NET374 NET376 NET401 FINAL_SRAM_G2
XI83 NET374 NET376 NET335 FINAL_SRAM_G2
XI82 NET374 NET376 NET411 FINAL_SRAM_G2
XI73 NET390 NET392 NET411 FINAL_SRAM_G2
XI72 NET390 NET392 NET335 FINAL_SRAM_G2
XI71 NET390 NET392 NET401 FINAL_SRAM_G2
XI70 NET390 NET392 NET403 FINAL_SRAM_G2
XI69 NET390 NET392 NET405 FINAL_SRAM_G2
XI68 NET390 NET392 NET407 FINAL_SRAM_G2
XI67 NET390 NET392 NET409 FINAL_SRAM_G2
XI66 NET390 NET392 NET413 FINAL_SRAM_G2
XI65 NET390 NET392 NET415 FINAL_SRAM_G2
XI64 NET390 NET392 NET417 FINAL_SRAM_G2
XI63 NET390 NET392 NET419 FINAL_SRAM_G2
XI62 NET390 NET392 NET421 FINAL_SRAM_G2
XI61 NET390 NET392 NET423 FINAL_SRAM_G2
XI60 NET390 NET392 NET425 FINAL_SRAM_G2
XI59 NET390 NET392 NET427 FINAL_SRAM_G2
XI58 NET390 NET392 NET429 FINAL_SRAM_G2
XI57 NET388 NET386 NET429 FINAL_SRAM_G2
XI56 NET388 NET386 NET427 FINAL_SRAM_G2
XI55 NET388 NET386 NET425 FINAL_SRAM_G2
XI54 NET388 NET386 NET423 FINAL_SRAM_G2
XI53 NET388 NET386 NET421 FINAL_SRAM_G2
XI52 NET388 NET386 NET419 FINAL_SRAM_G2
XI51 NET388 NET386 NET417 FINAL_SRAM_G2
XI50 NET388 NET386 NET415 FINAL_SRAM_G2
XI49 NET388 NET386 NET413 FINAL_SRAM_G2
XI48 NET388 NET386 NET409 FINAL_SRAM_G2
XI47 NET388 NET386 NET407 FINAL_SRAM_G2
XI46 NET388 NET386 NET405 FINAL_SRAM_G2
XI45 NET388 NET386 NET403 FINAL_SRAM_G2
XI44 NET388 NET386 NET401 FINAL_SRAM_G2
XI43 NET388 NET386 NET335 FINAL_SRAM_G2
XI42 NET388 NET386 NET411 FINAL_SRAM_G2
XI37 NET396 NET394 NET411 FINAL_SRAM_G2
XI36 NET396 NET394 NET335 FINAL_SRAM_G2
XI35 NET396 NET394 NET401 FINAL_SRAM_G2
XI34 NET396 NET394 NET403 FINAL_SRAM_G2
XI33 NET396 NET394 NET405 FINAL_SRAM_G2
XI32 NET396 NET394 NET407 FINAL_SRAM_G2
XI31 NET396 NET394 NET409 FINAL_SRAM_G2
XI30 NET396 NET394 NET413 FINAL_SRAM_G2
XI29 NET396 NET394 NET415 FINAL_SRAM_G2
XI28 NET396 NET394 NET417 FINAL_SRAM_G2
XI27 NET396 NET394 NET419 FINAL_SRAM_G2
XI26 NET396 NET394 NET421 FINAL_SRAM_G2
XI25 NET396 NET394 NET423 FINAL_SRAM_G2
XI24 NET396 NET394 NET425 FINAL_SRAM_G2
XI23 NET396 NET394 NET427 FINAL_SRAM_G2
XI22 NET396 NET394 NET429 FINAL_SRAM_G2
XI289 NET366 NET368 NET411 FINAL_SRAM_G2
XI288 NET366 NET368 NET335 FINAL_SRAM_G2
XI287 NET366 NET368 NET401 FINAL_SRAM_G2
XI286 NET366 NET368 NET403 FINAL_SRAM_G2
XI285 NET366 NET368 NET405 FINAL_SRAM_G2
XI284 NET366 NET368 NET407 FINAL_SRAM_G2
XI283 NET366 NET368 NET409 FINAL_SRAM_G2
XI282 NET366 NET368 NET413 FINAL_SRAM_G2
XI281 NET366 NET368 NET415 FINAL_SRAM_G2
XI280 NET366 NET368 NET417 FINAL_SRAM_G2
XI279 NET366 NET368 NET419 FINAL_SRAM_G2
XI278 NET366 NET368 NET421 FINAL_SRAM_G2
XI277 NET366 NET368 NET423 FINAL_SRAM_G2
XI276 NET366 NET368 NET425 FINAL_SRAM_G2
XI275 NET366 NET368 NET427 FINAL_SRAM_G2
XI274 NET366 NET368 NET429 FINAL_SRAM_G2
XI273 NET364 NET362 NET429 FINAL_SRAM_G2
XI272 NET364 NET362 NET427 FINAL_SRAM_G2
XI271 NET364 NET362 NET425 FINAL_SRAM_G2
XI270 NET364 NET362 NET423 FINAL_SRAM_G2
XI269 NET364 NET362 NET421 FINAL_SRAM_G2
XI268 NET364 NET362 NET419 FINAL_SRAM_G2
XI267 NET364 NET362 NET417 FINAL_SRAM_G2
XI266 NET364 NET362 NET415 FINAL_SRAM_G2
XI265 NET364 NET362 NET413 FINAL_SRAM_G2
XI264 NET364 NET362 NET409 FINAL_SRAM_G2
XI263 NET364 NET362 NET407 FINAL_SRAM_G2
XI262 NET364 NET362 NET405 FINAL_SRAM_G2
XI261 NET364 NET362 NET403 FINAL_SRAM_G2
XI260 NET364 NET362 NET401 FINAL_SRAM_G2
XI259 NET364 NET362 NET335 FINAL_SRAM_G2
XI258 NET364 NET362 NET411 FINAL_SRAM_G2
XI257 NET356 NET354 NET411 FINAL_SRAM_G2
XI256 NET356 NET354 NET335 FINAL_SRAM_G2
XI255 NET356 NET354 NET401 FINAL_SRAM_G2
XI254 NET356 NET354 NET403 FINAL_SRAM_G2
XI253 NET356 NET354 NET405 FINAL_SRAM_G2
XI252 NET356 NET354 NET407 FINAL_SRAM_G2
XI251 NET356 NET354 NET409 FINAL_SRAM_G2
XI250 NET356 NET354 NET413 FINAL_SRAM_G2
XI249 NET356 NET354 NET415 FINAL_SRAM_G2
XI248 NET356 NET354 NET417 FINAL_SRAM_G2
XI247 NET356 NET354 NET419 FINAL_SRAM_G2
XI246 NET356 NET354 NET421 FINAL_SRAM_G2
XI245 NET356 NET354 NET423 FINAL_SRAM_G2
XI244 NET356 NET354 NET425 FINAL_SRAM_G2
XI243 NET356 NET354 NET427 FINAL_SRAM_G2
XI242 NET356 NET354 NET429 FINAL_SRAM_G2
XI241 NET358 NET360 NET429 FINAL_SRAM_G2
XI240 NET358 NET360 NET427 FINAL_SRAM_G2
XI239 NET358 NET360 NET425 FINAL_SRAM_G2
XI238 NET358 NET360 NET423 FINAL_SRAM_G2
XI237 NET358 NET360 NET421 FINAL_SRAM_G2
XI236 NET358 NET360 NET419 FINAL_SRAM_G2
XI235 NET358 NET360 NET417 FINAL_SRAM_G2
XI234 NET358 NET360 NET415 FINAL_SRAM_G2
XI233 NET358 NET360 NET413 FINAL_SRAM_G2
XI232 NET358 NET360 NET409 FINAL_SRAM_G2
XI231 NET358 NET360 NET407 FINAL_SRAM_G2
XI230 NET358 NET360 NET405 FINAL_SRAM_G2
XI229 NET358 NET360 NET403 FINAL_SRAM_G2
XI228 NET358 NET360 NET401 FINAL_SRAM_G2
XI227 NET358 NET360 NET335 FINAL_SRAM_G2
XI226 NET358 NET360 NET411 FINAL_SRAM_G2
XI225 NET342 NET344 NET411 FINAL_SRAM_G2
XI224 NET342 NET344 NET335 FINAL_SRAM_G2
XI223 NET342 NET344 NET401 FINAL_SRAM_G2
XI222 NET342 NET344 NET403 FINAL_SRAM_G2
XI221 NET342 NET344 NET405 FINAL_SRAM_G2
XI220 NET342 NET344 NET407 FINAL_SRAM_G2
XI219 NET342 NET344 NET409 FINAL_SRAM_G2
XI218 NET342 NET344 NET413 FINAL_SRAM_G2
XI217 NET342 NET344 NET415 FINAL_SRAM_G2
XI216 NET342 NET344 NET417 FINAL_SRAM_G2
XI215 NET342 NET344 NET419 FINAL_SRAM_G2
XI214 NET342 NET344 NET421 FINAL_SRAM_G2
XI213 NET342 NET344 NET423 FINAL_SRAM_G2
XI212 NET342 NET344 NET425 FINAL_SRAM_G2
XI211 NET342 NET344 NET427 FINAL_SRAM_G2
XI210 NET342 NET344 NET429 FINAL_SRAM_G2
XI209 NET340 NET338 NET429 FINAL_SRAM_G2
XI208 NET340 NET338 NET427 FINAL_SRAM_G2
XI207 NET340 NET338 NET425 FINAL_SRAM_G2
XI206 NET340 NET338 NET423 FINAL_SRAM_G2
XI205 NET340 NET338 NET421 FINAL_SRAM_G2
XI204 NET340 NET338 NET419 FINAL_SRAM_G2
XI203 NET340 NET338 NET417 FINAL_SRAM_G2
XI202 NET340 NET338 NET415 FINAL_SRAM_G2
XI201 NET340 NET338 NET413 FINAL_SRAM_G2
XI200 NET340 NET338 NET409 FINAL_SRAM_G2
XI199 NET340 NET338 NET407 FINAL_SRAM_G2
XI198 NET340 NET338 NET405 FINAL_SRAM_G2
XI197 NET340 NET338 NET403 FINAL_SRAM_G2
XI196 NET340 NET338 NET401 FINAL_SRAM_G2
XI195 NET340 NET338 NET335 FINAL_SRAM_G2
XI194 NET340 NET338 NET411 FINAL_SRAM_G2
XI193 NET348 NET346 NET411 FINAL_SRAM_G2
XI192 NET348 NET346 NET335 FINAL_SRAM_G2
XI191 NET348 NET346 NET401 FINAL_SRAM_G2
XI190 NET348 NET346 NET403 FINAL_SRAM_G2
XI189 NET348 NET346 NET405 FINAL_SRAM_G2
XI188 NET348 NET346 NET407 FINAL_SRAM_G2
XI187 NET348 NET346 NET409 FINAL_SRAM_G2
XI186 NET348 NET346 NET413 FINAL_SRAM_G2
XI185 NET348 NET346 NET415 FINAL_SRAM_G2
XI184 NET348 NET346 NET417 FINAL_SRAM_G2
XI183 NET348 NET346 NET419 FINAL_SRAM_G2
XI182 NET348 NET346 NET421 FINAL_SRAM_G2
XI181 NET348 NET346 NET423 FINAL_SRAM_G2
XI180 NET348 NET346 NET425 FINAL_SRAM_G2
XI179 NET348 NET346 NET427 FINAL_SRAM_G2
XI178 NET348 NET346 NET429 FINAL_SRAM_G2
XI177 NET350 NET352 NET429 FINAL_SRAM_G2
XI176 NET350 NET352 NET427 FINAL_SRAM_G2
XI175 NET350 NET352 NET425 FINAL_SRAM_G2
XI174 NET350 NET352 NET423 FINAL_SRAM_G2
XI173 NET350 NET352 NET421 FINAL_SRAM_G2
XI172 NET350 NET352 NET419 FINAL_SRAM_G2
XI171 NET350 NET352 NET417 FINAL_SRAM_G2
XI170 NET350 NET352 NET415 FINAL_SRAM_G2
XI169 NET350 NET352 NET413 FINAL_SRAM_G2
XI168 NET350 NET352 NET409 FINAL_SRAM_G2
XI167 NET350 NET352 NET407 FINAL_SRAM_G2
XI166 NET350 NET352 NET405 FINAL_SRAM_G2
XI165 NET350 NET352 NET403 FINAL_SRAM_G2
XI164 NET350 NET352 NET401 FINAL_SRAM_G2
XI163 NET350 NET352 NET335 FINAL_SRAM_G2
XI162 NET350 NET352 NET411 FINAL_SRAM_G2
XI17 NET398 NET400 NET429 FINAL_SRAM_G2
XI16 NET398 NET400 NET427 FINAL_SRAM_G2
XI15 NET398 NET400 NET425 FINAL_SRAM_G2
XI14 NET398 NET400 NET423 FINAL_SRAM_G2
XI13 NET398 NET400 NET421 FINAL_SRAM_G2
XI12 NET398 NET400 NET419 FINAL_SRAM_G2
XI11 NET398 NET400 NET417 FINAL_SRAM_G2
XI10 NET398 NET400 NET415 FINAL_SRAM_G2
XI9 NET398 NET400 NET413 FINAL_SRAM_G2
XI8 NET398 NET400 NET409 FINAL_SRAM_G2
XI7 NET398 NET400 NET407 FINAL_SRAM_G2
XI6 NET398 NET400 NET405 FINAL_SRAM_G2
XI5 NET398 NET400 NET403 FINAL_SRAM_G2
XI4 NET398 NET400 NET401 FINAL_SRAM_G2
XI3 NET398 NET400 NET335 FINAL_SRAM_G2
XI2 NET398 NET400 NET411 FINAL_SRAM_G2
XI1 A0 A1 A2 A3 WL0 WL1 WL2 WL3 WL4 WL5 WL6 WL7 WL8 WL9 WL10 WL11 WL12 WL13
+WL14 WL15 FINAL_DECODER_G3

* FILE NAME: ECE471_LIB_FINAL_DECODER_SCHEMATIC.S.
* SUBCIRCUIT FOR CELL: FINAL_DECODER.
* GENERATED FOR: HSPICES.
* GENERATED ON MAR 15 19:21:34 2014.

* TERMINAL MAPPING: A0 = A0
*                   A1 = A1
*                   A2 = A2
*                   A3 = A3
*                   WL0 = WL0
*                   WL1 = WL1
*                   WL2 = WL2
*                   WL3 = WL3
*                   WL4 = WL4
*                   WL5 = WL5
*                   WL6 = WL6
*                   WL7 = WL7
*                   WL8 = WL8
*                   WL9 = WL9
*                   WL10 = WL10
*                   WL11 = WL11
*                   WL12 = WL12
*                   WL13 = WL13
*                   WL14 = WL14
*                   WL15 = WL15
.SUBCKT FINAL_DECODER_G3 A0 A1 A2 A3 WL0 WL1 WL2 WL3 WL4 WL5 WL6 WL7 WL8 WL9
+WL10 WL11 WL12 WL13 WL14 WL15
XI18 A2 2 SUB1
XI20 A0 4 SUB1
XI17 A3 1 SUB1
XI19 A1 3 SUB1
XI15 1 2 3 4 WL0 FINAL_AND4_G1
XI14 1 2 3 A0 WL1 FINAL_AND4_G1
XI13 1 2 A1 4 WL2 FINAL_AND4_G1
XI12 1 2 A1 A0 WL3 FINAL_AND4_G1
XI11 1 A2 3 4 WL4 FINAL_AND4_G1
XI10 1 A2 3 A0 WL5 FINAL_AND4_G1
XI9 1 A2 A1 4 WL6 FINAL_AND4_G1
XI8 1 A2 A1 A0 WL7 FINAL_AND4_G1
XI7 A3 A2 A1 A0 WL15 FINAL_AND4_G1
XI6 A3 A2 A1 4 WL14 FINAL_AND4_G1
XI5 A3 A2 3 A0 WL13 FINAL_AND4_G1
XI4 A3 A2 3 4 WL12 FINAL_AND4_G1
XI3 A3 2 A1 A0 WL11 FINAL_AND4_G1
XI2 A3 2 A1 4 WL10 FINAL_AND4_G1
XI1 A3 2 3 A0 WL9 FINAL_AND4_G1
XI0 A3 2 3 4 WL8 FINAL_AND4_G1

* END OF SUBCIRCUIT DEFINITION.
.ENDS FINAL_DECODER_G3
* FILE NAME: ECE471_LIB_FINAL_SRAM_SCHEMATIC.S.
* SUBCIRCUIT FOR CELL: FINAL_SRAM.
* GENERATED FOR: HSPICES.
* GENERATED ON MAR 15 19:21:34 2014.

* TERMINAL MAPPING: -BL = 1
*                   BL = BL
*                   WL = WL
.SUBCKT FINAL_SRAM_G2 1 BL WL
MN4 BL WL NET7 0  TSMC25DN  L=240E-9 W=360E-9 AD=216E-15 AS=216E-15 PD=1.92E-6
+PS=1.92E-6 M=1
MN2 1 WL NET14 0  TSMC25DN  L=240E-9 W=360E-9 AD=216E-15 AS=216E-15 PD=1.92E-6
+PS=1.92E-6 M=1
MN1 NET7 NET14 0 0  TSMC25DN  L=240E-9 W=360E-9 AD=216E-15 AS=216E-15
+PD=1.92E-6 PS=1.92E-6 M=1
MN0 NET14 NET7 0 0  TSMC25DN  L=240E-9 W=360E-9 AD=216E-15 AS=216E-15
+PD=1.92E-6 PS=1.92E-6 M=1
MP1 NET7 NET14 VDD! VDD!  TSMC25DP  L=240E-9 W=360E-9 AD=216E-15 AS=216E-15
+PD=1.92E-6 PS=1.92E-6 M=1
MP0 NET14 NET7 VDD! VDD!  TSMC25DP  L=240E-9 W=360E-9 AD=216E-15 AS=216E-15
+PD=1.92E-6 PS=1.92E-6 M=1

* END OF SUBCIRCUIT DEFINITION.
.ENDS FINAL_SRAM_G2
* FILE NAME: ECE471_LIB_FINAL_AND4_SCHEMATIC.S.
* SUBCIRCUIT FOR CELL: FINAL_AND4.
* GENERATED FOR: HSPICES.
* GENERATED ON MAR 15 19:21:34 2014.

* TERMINAL MAPPING: A = A
*                   B = B
*                   C = C
*                   D = D
*                   Y = Y
.SUBCKT FINAL_AND4_G1 A B C D Y
MN4 NET6 D 0 0  TSMC25DN  L=240E-9 W=2.88E-6 AD=1.728E-12 AS=1.728E-12
+PD=6.96E-6 PS=6.96E-6 M=1
MN0 Y NET42 0 0  TSMC25DN  L=240E-9 W=360E-9 AD=216E-15 AS=216E-15 PD=1.92E-6
+PS=1.92E-6 M=1
MN1 NET42 A NET14 0  TSMC25DN  L=240E-9 W=720E-9 AD=432E-15 AS=432E-15
+PD=2.64E-6 PS=2.64E-6 M=1
MN2 NET14 B NET10 0  TSMC25DN  L=240E-9 W=1.44E-6 AD=864E-15 AS=864E-15
+PD=4.08E-6 PS=4.08E-6 M=1
MN3 NET10 C NET6 0  TSMC25DN  L=240E-9 W=2.88E-6 AD=1.728E-12 AS=1.728E-12
+PD=6.96E-6 PS=6.96E-6 M=1
MP4 Y NET42 VDD! VDD!  TSMC25DP  L=240E-9 W=720E-9 AD=432E-15 AS=432E-15
+PD=2.64E-6 PS=2.64E-6 M=1
MP3 NET42 D VDD! VDD!  TSMC25DP  L=240E-9 W=720E-9 AD=432E-15 AS=432E-15
+PD=2.64E-6 PS=2.64E-6 M=1
MP2 NET42 C VDD! VDD!  TSMC25DP  L=240E-9 W=720E-9 AD=432E-15 AS=432E-15
+PD=2.64E-6 PS=2.64E-6 M=1
MP1 NET42 B VDD! VDD!  TSMC25DP  L=240E-9 W=720E-9 AD=432E-15 AS=432E-15
+PD=2.64E-6 PS=2.64E-6 M=1
MP0 NET42 A VDD! VDD!  TSMC25DP  L=240E-9 W=720E-9 AD=432E-15 AS=432E-15
+PD=2.64E-6 PS=2.64E-6 M=1

* END OF SUBCIRCUIT DEFINITION.
.ENDS FINAL_AND4_G1
* FILE NAME: ECE471_LIB_FINAL_INVERTER_SCHEMATIC.S.
* SUBCIRCUIT FOR CELL: FINAL_INVERTER.
* GENERATED FOR: HSPICES.
* GENERATED ON MAR 15 19:21:34 2014.

* TERMINAL MAPPING: IN = IN
*                   OUT = OUT
.SUBCKT SUB1 IN OUT
MP0 OUT IN VDD! VDD!  TSMC25DP  L=240E-9 W=720E-9 AD=432E-15 AS=432E-15
+PD=2.64E-6 PS=2.64E-6 M=1
MN0 OUT IN 0 0  TSMC25DN  L=240E-9 W=360E-9 AD=216E-15 AS=216E-15 PD=1.92E-6
+PS=1.92E-6 M=1

* END OF SUBCIRCUIT DEFINITION.
.ENDS SUB1
* FILE NAME: ECE471_LIB_FINAL_TRISTATE_SCHEMATIC.S.
* SUBCIRCUIT FOR CELL: FINAL_TRISTATE.
* GENERATED FOR: HSPICES.
* GENERATED ON MAR 15 19:21:34 2014.

* TERMINAL MAPPING: A = A
*                   EN = EN
*                   Y = Y
.SUBCKT SUB2 A EN Y
XI0 EN 1 SUB1
MN2 NET6 A 0 0  TSMC25DN  L=240E-9 W=360E-9 AD=216E-15 AS=216E-15 PD=1.92E-6
+PS=1.92E-6 M=1
MN1 NET10 NET6 0 0  TSMC25DN  L=240E-9 W=720E-9 AD=432E-15 AS=432E-15
+PD=2.64E-6 PS=2.64E-6 M=1
MN0 Y EN NET10 0  TSMC25DN  L=240E-9 W=720E-9 AD=432E-15 AS=432E-15 PD=2.64E-6
+PS=2.64E-6 M=1
MP2 Y 1 NET21 VDD!  TSMC25DP  L=240E-9 W=1.44E-6 AD=864E-15 AS=864E-15
+PD=4.08E-6 PS=4.08E-6 M=1
MP1 NET21 NET6 VDD! VDD!  TSMC25DP  L=240E-9 W=1.44E-6 AD=864E-15 AS=864E-15
+PD=4.08E-6 PS=4.08E-6 M=1
MP0 NET6 A VDD! VDD!  TSMC25DP  L=240E-9 W=720E-9 AD=432E-15 AS=432E-15
+PD=2.64E-6 PS=2.64E-6 M=1

* END OF SUBCIRCUIT DEFINITION.
.ENDS SUB2

.lib "/nfs/guille/u1/c/cdsmgr/cdsmgr/pdk/CDK1.4/local/models/hspice/public/publicModel/tsmc25dN" NMOS
.lib "/nfs/guille/u1/c/cdsmgr/cdsmgr/pdk/CDK1.4/local/models/hspice/public/publicModel/tsmc25dP" PMOS

* INCLUDE FILES

* END OF NETLIST
.TEMP    25.0000
.OP
.save
.OPTION  INGOLD=2 ARTIST=2 PSF=2
+        PROBE=0
.END
