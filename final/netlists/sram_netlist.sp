* # FILE NAME: /NFS/STAK/STUDENTS/B/BRANAUGJ/CADENCE/SIMULATION/FINAL/
* HSPICES/SCHEMATIC/NETLIST/FINAL.C.RAW
* NETLIST OUTPUT FOR HSPICES.
* GENERATED ON MAR 19 17:52:07 2014

* GLOBAL NET DEFINITIONS
.GLOBAL VDD!
* FILE NAME: ECE471_LIB_FINAL_SCHEMATIC.S.
* SUBCIRCUIT FOR CELL: FINAL.
* GENERATED FOR: HSPICES.
* GENERATED ON MAR 19 17:52:07 2014.

XI437 PRE NET368 NET366 SUB2
XI436 PRE NET362 NET364 SUB2
XI435 PRE NET360 NET358 SUB2
XI434 PRE NET354 NET356 SUB2
XI433 PRE NET344 NET342 SUB2
XI432 PRE NET338 NET340 SUB2
XI431 PRE NET352 NET350 SUB2
XI430 PRE NET346 NET348 SUB2
XI429 PRE NET378 NET380 SUB2
XI428 PRE NET384 NET382 SUB2
XI427 PRE NET370 NET372 SUB2
XI426 PRE NET376 NET374 SUB2
XI425 PRE NET392 NET390 SUB2
XI424 PRE NET386 NET388 SUB2
XI423 PRE NET394 NET396 SUB2
XI422 PRE NET400 NET398 SUB2
XI403 RD_EN NET400 NET398 RD15 SUB3
XI404 RD_EN NET394 NET396 RD14 SUB3
XI405 RD_EN NET392 NET390 RD13 SUB3
XI406 RD_EN NET386 NET388 RD12 SUB3
XI413 RD_EN NET352 NET350 RD3 SUB3
XI414 RD_EN NET346 NET348 RD2 SUB3
XI407 RD_EN NET378 NET380 RD10 SUB3
XI408 RD_EN NET384 NET382 RD11 SUB3
XI415 RD_EN NET338 NET340 RD0 SUB3
XI416 RD_EN NET344 NET342 RD1 SUB3
XI417 RD_EN NET360 NET358 RD5 SUB3
XI418 RD_EN NET354 NET356 RD4 SUB3
XI409 RD_EN NET368 NET366 RD7 SUB3
XI412 RD_EN NET376 NET374 RD9 SUB3
XI411 RD_EN NET370 NET372 RD8 SUB3
XI410 RD_EN NET362 NET364 RD6 SUB3
XI372 NET0344 WR_EN NET458 SUB4
XI387 WR5 WR_EN NET0690 SUB4
XI366 NET0404 WR_EN NET460 SUB4
XI369 WR11 WR_EN NET0621 SUB4
XI370 WR10 WR_EN NET0630 SUB4
XI367 NET0402 WR_EN NET456 SUB4
XI363 WR13 WR_EN NET0645 SUB4
XI364 WR12 WR_EN NET0654 SUB4
XI361 NET0365 WR_EN NET452 SUB4
XI360 NET0408 WR_EN NET454 SUB4
XI358 WR14 WR_EN NET0657 SUB4
XI356 NET0410 WR_EN NET448 SUB4
XI388 WR4 WR_EN NET0681 SUB4
XI385 NET0390 WR_EN NET444 SUB4
XI390 NET0388 WR_EN NET446 SUB4
XI357 WR15 WR_EN NET0666 SUB4
XI396 NET0384 WR_EN NET442 SUB4
XI391 NET0305 WR_EN NET462 SUB4
XI373 NET0341 WR_EN NET450 SUB4
XI381 WR7 WR_EN NET0669 SUB4
XI397 NET0382 WR_EN NET438 SUB4
XI376 WR8 WR_EN NET0633 SUB4
XI382 WR6 WR_EN NET0678 SUB4
XI378 NET0332 WR_EN NET432 SUB4
XI393 WR3 WR_EN NET0714 SUB4
XI399 WR1 WR_EN NET0693 SUB4
XI400 WR0 WR_EN NET0702 SUB4
XI402 NET0284 WR_EN NET440 SUB4
XI375 WR9 WR_EN NET0642 SUB4
XI384 NET0320 WR_EN NET434 SUB4
XI379 NET0329 WR_EN NET436 SUB4
XI394 WR2 WR_EN NET0705 SUB4
XI368 WR11 NET0402 SUB1
XI371 WR10 NET0344 SUB1
XI365 WR12 NET0404 SUB1
XI362 WR13 NET0365 SUB1
XI359 WR14 NET0408 SUB1
XI355 WR15 NET0410 SUB1
XI386 WR5 NET0390 SUB1
XI389 WR4 NET0388 SUB1
XI395 WR2 NET0384 SUB1
XI374 WR9 NET0341 SUB1
XI392 WR3 NET0305 SUB1
XI398 WR1 NET0382 SUB1
XI377 WR8 NET0332 SUB1
XI401 WR0 NET0284 SUB1
XI380 WR7 NET0329 SUB1
XI383 WR6 NET0320 SUB1
C30 NET400 0  15.8E-15 M=1.0
C31 NET0666 0  15.8E-15 M=1.0
C35 NET398 0  15.8E-15 M=1.0
C34 NET448 0  15.8E-15 M=1.0
C36 NET396 0  15.8E-15 M=1.0
C37 NET454 0  15.8E-15 M=1.0
C38 NET0657 0  15.8E-15 M=1.0
C39 NET394 0  15.8E-15 M=1.0
C40 NET392 0  15.8E-15 M=1.0
C41 NET0645 0  15.8E-15 M=1.0
C42 NET452 0  15.8E-15 M=1.0
C43 NET390 0  15.8E-15 M=1.0
C44 NET388 0  15.8E-15 M=1.0
C45 NET460 0  15.8E-15 M=1.0
C46 NET0654 0  15.8E-15 M=1.0
C47 NET386 0  15.8E-15 M=1.0
C48 NET384 0  15.8E-15 M=1.0
C49 NET0621 0  15.8E-15 M=1.0
C50 NET456 0  15.8E-15 M=1.0
C51 NET382 0  15.8E-15 M=1.0
C52 NET380 0  15.8E-15 M=1.0
C53 NET458 0  15.8E-15 M=1.0
C54 NET0630 0  15.8E-15 M=1.0
C55 NET378 0  15.8E-15 M=1.0
C56 NET376 0  15.8E-15 M=1.0
C57 NET0642 0  15.8E-15 M=1.0
C58 NET450 0  15.8E-15 M=1.0
C59 NET374 0  15.8E-15 M=1.0
C60 NET372 0  15.8E-15 M=1.0
C61 NET432 0  15.8E-15 M=1.0
C62 NET0633 0  15.8E-15 M=1.0
C63 NET370 0  15.8E-15 M=1.0
C64 NET368 0  15.8E-15 M=1.0
C65 NET0669 0  15.8E-15 M=1.0
C66 NET436 0  15.8E-15 M=1.0
C67 NET366 0  15.8E-15 M=1.0
C68 NET364 0  15.8E-15 M=1.0
C69 NET434 0  15.8E-15 M=1.0
C70 NET0678 0  15.8E-15 M=1.0
C71 NET362 0  15.8E-15 M=1.0
C72 NET360 0  15.8E-15 M=1.0
C73 NET0690 0  15.8E-15 M=1.0
C74 NET444 0  15.8E-15 M=1.0
C75 NET358 0  15.8E-15 M=1.0
C76 NET356 0  15.8E-15 M=1.0
C77 NET446 0  15.8E-15 M=1.0
C78 NET0681 0  15.8E-15 M=1.0
C79 NET354 0  15.8E-15 M=1.0
C80 NET352 0  15.8E-15 M=1.0
C81 NET0714 0  15.8E-15 M=1.0
C82 NET462 0  15.8E-15 M=1.0
C83 NET350 0  15.8E-15 M=1.0
C84 NET348 0  15.8E-15 M=1.0
C85 NET442 0  15.8E-15 M=1.0
C86 NET0705 0  15.8E-15 M=1.0
C87 NET346 0  15.8E-15 M=1.0
C88 NET344 0  15.8E-15 M=1.0
C89 NET0693 0  15.8E-15 M=1.0
C90 NET438 0  15.8E-15 M=1.0
C91 NET342 0  15.8E-15 M=1.0
C92 NET340 0  15.8E-15 M=1.0
C93 NET440 0  15.8E-15 M=1.0
C94 NET0702 0  15.8E-15 M=1.0
C95 NET338 0  15.8E-15 M=1.0
C2 NET401 0  23.7E-15 M=1.0
C3 WL2 0  23.7E-15 M=1.0
C4 WL3 0  23.7E-15 M=1.0
C5 NET403 0  23.7E-15 M=1.0
C1 NET411 0  23.7E-15 M=1.0
C6 NET405 0  23.7E-15 M=1.0
C7 WL4 0  23.7E-15 M=1.0
C8 WL5 0  23.7E-15 M=1.0
C9 NET407 0  23.7E-15 M=1.0
C0 WL0 0  23.7E-15 M=1.0
C10 WL6 0  23.7E-15 M=1.0
C11 NET409 0  23.7E-15 M=1.0
C12 NET413 0  23.7E-15 M=1.0
C13 WL7 0  23.7E-15 M=1.0
C14 WL8 0  23.7E-15 M=1.0
C15 NET415 0  23.7E-15 M=1.0
C16 NET417 0  23.7E-15 M=1.0
C17 WL9 0  23.7E-15 M=1.0
C18 WL10 0  23.7E-15 M=1.0
C19 NET419 0  23.7E-15 M=1.0
C20 NET421 0  23.7E-15 M=1.0
C21 WL11 0  23.7E-15 M=1.0
C22 WL12 0  23.7E-15 M=1.0
C23 NET423 0  23.7E-15 M=1.0
C24 NET425 0  23.7E-15 M=1.0
C25 WL13 0  23.7E-15 M=1.0
C26 WL14 0  23.7E-15 M=1.0
C27 NET427 0  23.7E-15 M=1.0
C28 NET429 0  23.7E-15 M=1.0
C29 WL15 0  23.7E-15 M=1.0
C96 NET335 0  23.7E-15 M=1.0
C97 WL1 0  23.7E-15 M=1.0
R15 NET400 NET0666  48.0 M=1.0
R17 NET398 NET448  48.0 M=1.0
R18 NET396 NET454  48.0 M=1.0
R19 NET394 NET0657  48.0 M=1.0
R20 NET392 NET0645  48.0 M=1.0
R21 NET390 NET452  48.0 M=1.0
R22 NET388 NET460  48.0 M=1.0
R23 NET386 NET0654  48.0 M=1.0
R24 NET384 NET0621  48.0 M=1.0
R25 NET382 NET456  48.0 M=1.0
R26 NET380 NET458  48.0 M=1.0
R27 NET378 NET0630  48.0 M=1.0
R28 NET376 NET0642  48.0 M=1.0
R29 NET374 NET450  48.0 M=1.0
R30 NET372 NET432  48.0 M=1.0
R31 NET370 NET0633  48.0 M=1.0
R32 NET368 NET0669  48.0 M=1.0
R33 NET366 NET436  48.0 M=1.0
R34 NET364 NET434  48.0 M=1.0
R35 NET362 NET0678  48.0 M=1.0
R36 NET360 NET0690  48.0 M=1.0
R37 NET358 NET444  48.0 M=1.0
R38 NET356 NET446  48.0 M=1.0
R39 NET354 NET0681  48.0 M=1.0
R40 NET352 NET0714  48.0 M=1.0
R41 NET350 NET462  48.0 M=1.0
R42 NET348 NET442  48.0 M=1.0
R43 NET346 NET0705  48.0 M=1.0
R44 NET344 NET0693  48.0 M=1.0
R45 NET342 NET438  48.0 M=1.0
R46 NET340 NET440  48.0 M=1.0
R47 NET338 NET0702  48.0 M=1.0
R1 WL2 NET401  72.0 M=1.0
R2 WL3 NET403  72.0 M=1.0
R3 WL4 NET405  72.0 M=1.0
R4 WL5 NET407  72.0 M=1.0
R5 WL6 NET409  72.0 M=1.0
R0 WL0 NET411  72.0 M=1.0
R6 WL7 NET413  72.0 M=1.0
R7 WL8 NET415  72.0 M=1.0
R8 WL9 NET417  72.0 M=1.0
R9 WL10 NET419  72.0 M=1.0
R10 WL11 NET421  72.0 M=1.0
R11 WL12 NET423  72.0 M=1.0
R12 WL13 NET425  72.0 M=1.0
R13 WL14 NET427  72.0 M=1.0
R14 WL15 NET429  72.0 M=1.0
R48 WL1 NET335  72.0 M=1.0
XI145 NET384 NET382 NET411 FINAL_SRAM_G2
XI144 NET384 NET382 NET335 FINAL_SRAM_G2
XI143 NET384 NET382 NET401 FINAL_SRAM_G2
XI142 NET384 NET382 NET403 FINAL_SRAM_G2
XI141 NET384 NET382 NET405 FINAL_SRAM_G2
XI140 NET384 NET382 NET407 FINAL_SRAM_G2
XI139 NET384 NET382 NET409 FINAL_SRAM_G2
XI138 NET384 NET382 NET413 FINAL_SRAM_G2
XI137 NET384 NET382 NET415 FINAL_SRAM_G2
XI136 NET384 NET382 NET417 FINAL_SRAM_G2
XI135 NET384 NET382 NET419 FINAL_SRAM_G2
XI134 NET384 NET382 NET421 FINAL_SRAM_G2
XI133 NET384 NET382 NET423 FINAL_SRAM_G2
XI132 NET384 NET382 NET425 FINAL_SRAM_G2
XI131 NET384 NET382 NET427 FINAL_SRAM_G2
XI130 NET384 NET382 NET429 FINAL_SRAM_G2
XI129 NET378 NET380 NET429 FINAL_SRAM_G2
XI128 NET378 NET380 NET427 FINAL_SRAM_G2
XI127 NET378 NET380 NET425 FINAL_SRAM_G2
XI126 NET378 NET380 NET423 FINAL_SRAM_G2
XI125 NET378 NET380 NET421 FINAL_SRAM_G2
XI124 NET378 NET380 NET419 FINAL_SRAM_G2
XI123 NET378 NET380 NET417 FINAL_SRAM_G2
XI122 NET378 NET380 NET415 FINAL_SRAM_G2
XI121 NET378 NET380 NET413 FINAL_SRAM_G2
XI120 NET378 NET380 NET409 FINAL_SRAM_G2
XI119 NET378 NET380 NET407 FINAL_SRAM_G2
XI118 NET378 NET380 NET405 FINAL_SRAM_G2
XI117 NET378 NET380 NET403 FINAL_SRAM_G2
XI116 NET378 NET380 NET401 FINAL_SRAM_G2
XI115 NET378 NET380 NET335 FINAL_SRAM_G2
XI114 NET378 NET380 NET411 FINAL_SRAM_G2
XI113 NET370 NET372 NET411 FINAL_SRAM_G2
XI112 NET370 NET372 NET335 FINAL_SRAM_G2
XI111 NET370 NET372 NET401 FINAL_SRAM_G2
XI110 NET370 NET372 NET403 FINAL_SRAM_G2
XI109 NET370 NET372 NET405 FINAL_SRAM_G2
XI108 NET370 NET372 NET407 FINAL_SRAM_G2
XI107 NET370 NET372 NET409 FINAL_SRAM_G2
XI106 NET370 NET372 NET413 FINAL_SRAM_G2
XI105 NET370 NET372 NET415 FINAL_SRAM_G2
XI104 NET370 NET372 NET417 FINAL_SRAM_G2
XI103 NET370 NET372 NET419 FINAL_SRAM_G2
XI102 NET370 NET372 NET421 FINAL_SRAM_G2
XI101 NET370 NET372 NET423 FINAL_SRAM_G2
XI100 NET370 NET372 NET425 FINAL_SRAM_G2
XI99 NET370 NET372 NET427 FINAL_SRAM_G2
XI98 NET370 NET372 NET429 FINAL_SRAM_G2
XI97 NET376 NET374 NET429 FINAL_SRAM_G2
XI96 NET376 NET374 NET427 FINAL_SRAM_G2
XI95 NET376 NET374 NET425 FINAL_SRAM_G2
XI94 NET376 NET374 NET423 FINAL_SRAM_G2
XI93 NET376 NET374 NET421 FINAL_SRAM_G2
XI92 NET376 NET374 NET419 FINAL_SRAM_G2
XI91 NET376 NET374 NET417 FINAL_SRAM_G2
XI90 NET376 NET374 NET415 FINAL_SRAM_G2
XI89 NET376 NET374 NET413 FINAL_SRAM_G2
XI88 NET376 NET374 NET409 FINAL_SRAM_G2
XI87 NET376 NET374 NET407 FINAL_SRAM_G2
XI86 NET376 NET374 NET405 FINAL_SRAM_G2
XI85 NET376 NET374 NET403 FINAL_SRAM_G2
XI84 NET376 NET374 NET401 FINAL_SRAM_G2
XI83 NET376 NET374 NET335 FINAL_SRAM_G2
XI82 NET376 NET374 NET411 FINAL_SRAM_G2
XI73 NET392 NET390 NET411 FINAL_SRAM_G2
XI72 NET392 NET390 NET335 FINAL_SRAM_G2
XI71 NET392 NET390 NET401 FINAL_SRAM_G2
XI70 NET392 NET390 NET403 FINAL_SRAM_G2
XI69 NET392 NET390 NET405 FINAL_SRAM_G2
XI68 NET392 NET390 NET407 FINAL_SRAM_G2
XI67 NET392 NET390 NET409 FINAL_SRAM_G2
XI66 NET392 NET390 NET413 FINAL_SRAM_G2
XI65 NET392 NET390 NET415 FINAL_SRAM_G2
XI64 NET392 NET390 NET417 FINAL_SRAM_G2
XI63 NET392 NET390 NET419 FINAL_SRAM_G2
XI62 NET392 NET390 NET421 FINAL_SRAM_G2
XI61 NET392 NET390 NET423 FINAL_SRAM_G2
XI60 NET392 NET390 NET425 FINAL_SRAM_G2
XI59 NET392 NET390 NET427 FINAL_SRAM_G2
XI58 NET392 NET390 NET429 FINAL_SRAM_G2
XI57 NET386 NET388 NET429 FINAL_SRAM_G2
XI56 NET386 NET388 NET427 FINAL_SRAM_G2
XI55 NET386 NET388 NET425 FINAL_SRAM_G2
XI54 NET386 NET388 NET423 FINAL_SRAM_G2
XI53 NET386 NET388 NET421 FINAL_SRAM_G2
XI52 NET386 NET388 NET419 FINAL_SRAM_G2
XI51 NET386 NET388 NET417 FINAL_SRAM_G2
XI50 NET386 NET388 NET415 FINAL_SRAM_G2
XI49 NET386 NET388 NET413 FINAL_SRAM_G2
XI48 NET386 NET388 NET409 FINAL_SRAM_G2
XI47 NET386 NET388 NET407 FINAL_SRAM_G2
XI46 NET386 NET388 NET405 FINAL_SRAM_G2
XI45 NET386 NET388 NET403 FINAL_SRAM_G2
XI44 NET386 NET388 NET401 FINAL_SRAM_G2
XI43 NET386 NET388 NET335 FINAL_SRAM_G2
XI42 NET386 NET388 NET411 FINAL_SRAM_G2
XI37 NET394 NET396 NET411 FINAL_SRAM_G2
XI36 NET394 NET396 NET335 FINAL_SRAM_G2
XI35 NET394 NET396 NET401 FINAL_SRAM_G2
XI34 NET394 NET396 NET403 FINAL_SRAM_G2
XI33 NET394 NET396 NET405 FINAL_SRAM_G2
XI32 NET394 NET396 NET407 FINAL_SRAM_G2
XI31 NET394 NET396 NET409 FINAL_SRAM_G2
XI30 NET394 NET396 NET413 FINAL_SRAM_G2
XI29 NET394 NET396 NET415 FINAL_SRAM_G2
XI28 NET394 NET396 NET417 FINAL_SRAM_G2
XI27 NET394 NET396 NET419 FINAL_SRAM_G2
XI26 NET394 NET396 NET421 FINAL_SRAM_G2
XI25 NET394 NET396 NET423 FINAL_SRAM_G2
XI24 NET394 NET396 NET425 FINAL_SRAM_G2
XI23 NET394 NET396 NET427 FINAL_SRAM_G2
XI22 NET394 NET396 NET429 FINAL_SRAM_G2
XI289 NET368 NET366 NET411 FINAL_SRAM_G2
XI288 NET368 NET366 NET335 FINAL_SRAM_G2
XI287 NET368 NET366 NET401 FINAL_SRAM_G2
XI286 NET368 NET366 NET403 FINAL_SRAM_G2
XI285 NET368 NET366 NET405 FINAL_SRAM_G2
XI284 NET368 NET366 NET407 FINAL_SRAM_G2
XI283 NET368 NET366 NET409 FINAL_SRAM_G2
XI282 NET368 NET366 NET413 FINAL_SRAM_G2
XI281 NET368 NET366 NET415 FINAL_SRAM_G2
XI280 NET368 NET366 NET417 FINAL_SRAM_G2
XI279 NET368 NET366 NET419 FINAL_SRAM_G2
XI278 NET368 NET366 NET421 FINAL_SRAM_G2
XI277 NET368 NET366 NET423 FINAL_SRAM_G2
XI276 NET368 NET366 NET425 FINAL_SRAM_G2
XI275 NET368 NET366 NET427 FINAL_SRAM_G2
XI274 NET368 NET366 NET429 FINAL_SRAM_G2
XI273 NET362 NET364 NET429 FINAL_SRAM_G2
XI272 NET362 NET364 NET427 FINAL_SRAM_G2
XI271 NET362 NET364 NET425 FINAL_SRAM_G2
XI270 NET362 NET364 NET423 FINAL_SRAM_G2
XI269 NET362 NET364 NET421 FINAL_SRAM_G2
XI268 NET362 NET364 NET419 FINAL_SRAM_G2
XI267 NET362 NET364 NET417 FINAL_SRAM_G2
XI266 NET362 NET364 NET415 FINAL_SRAM_G2
XI265 NET362 NET364 NET413 FINAL_SRAM_G2
XI264 NET362 NET364 NET409 FINAL_SRAM_G2
XI263 NET362 NET364 NET407 FINAL_SRAM_G2
XI262 NET362 NET364 NET405 FINAL_SRAM_G2
XI261 NET362 NET364 NET403 FINAL_SRAM_G2
XI260 NET362 NET364 NET401 FINAL_SRAM_G2
XI259 NET362 NET364 NET335 FINAL_SRAM_G2
XI258 NET362 NET364 NET411 FINAL_SRAM_G2
XI257 NET354 NET356 NET411 FINAL_SRAM_G2
XI256 NET354 NET356 NET335 FINAL_SRAM_G2
XI255 NET354 NET356 NET401 FINAL_SRAM_G2
XI254 NET354 NET356 NET403 FINAL_SRAM_G2
XI253 NET354 NET356 NET405 FINAL_SRAM_G2
XI252 NET354 NET356 NET407 FINAL_SRAM_G2
XI251 NET354 NET356 NET409 FINAL_SRAM_G2
XI250 NET354 NET356 NET413 FINAL_SRAM_G2
XI249 NET354 NET356 NET415 FINAL_SRAM_G2
XI248 NET354 NET356 NET417 FINAL_SRAM_G2
XI247 NET354 NET356 NET419 FINAL_SRAM_G2
XI246 NET354 NET356 NET421 FINAL_SRAM_G2
XI245 NET354 NET356 NET423 FINAL_SRAM_G2
XI244 NET354 NET356 NET425 FINAL_SRAM_G2
XI243 NET354 NET356 NET427 FINAL_SRAM_G2
XI242 NET354 NET356 NET429 FINAL_SRAM_G2
XI241 NET360 NET358 NET429 FINAL_SRAM_G2
XI240 NET360 NET358 NET427 FINAL_SRAM_G2
XI239 NET360 NET358 NET425 FINAL_SRAM_G2
XI238 NET360 NET358 NET423 FINAL_SRAM_G2
XI237 NET360 NET358 NET421 FINAL_SRAM_G2
XI236 NET360 NET358 NET419 FINAL_SRAM_G2
XI235 NET360 NET358 NET417 FINAL_SRAM_G2
XI234 NET360 NET358 NET415 FINAL_SRAM_G2
XI233 NET360 NET358 NET413 FINAL_SRAM_G2
XI232 NET360 NET358 NET409 FINAL_SRAM_G2
XI231 NET360 NET358 NET407 FINAL_SRAM_G2
XI230 NET360 NET358 NET405 FINAL_SRAM_G2
XI229 NET360 NET358 NET403 FINAL_SRAM_G2
XI228 NET360 NET358 NET401 FINAL_SRAM_G2
XI227 NET360 NET358 NET335 FINAL_SRAM_G2
XI226 NET360 NET358 NET411 FINAL_SRAM_G2
XI225 NET344 NET342 NET411 FINAL_SRAM_G2
XI224 NET344 NET342 NET335 FINAL_SRAM_G2
XI223 NET344 NET342 NET401 FINAL_SRAM_G2
XI222 NET344 NET342 NET403 FINAL_SRAM_G2
XI221 NET344 NET342 NET405 FINAL_SRAM_G2
XI220 NET344 NET342 NET407 FINAL_SRAM_G2
XI219 NET344 NET342 NET409 FINAL_SRAM_G2
XI218 NET344 NET342 NET413 FINAL_SRAM_G2
XI217 NET344 NET342 NET415 FINAL_SRAM_G2
XI216 NET344 NET342 NET417 FINAL_SRAM_G2
XI215 NET344 NET342 NET419 FINAL_SRAM_G2
XI214 NET344 NET342 NET421 FINAL_SRAM_G2
XI213 NET344 NET342 NET423 FINAL_SRAM_G2
XI212 NET344 NET342 NET425 FINAL_SRAM_G2
XI211 NET344 NET342 NET427 FINAL_SRAM_G2
XI210 NET344 NET342 NET429 FINAL_SRAM_G2
XI209 NET338 NET340 NET429 FINAL_SRAM_G2
XI208 NET338 NET340 NET427 FINAL_SRAM_G2
XI207 NET338 NET340 NET425 FINAL_SRAM_G2
XI206 NET338 NET340 NET423 FINAL_SRAM_G2
XI205 NET338 NET340 NET421 FINAL_SRAM_G2
XI204 NET338 NET340 NET419 FINAL_SRAM_G2
XI203 NET338 NET340 NET417 FINAL_SRAM_G2
XI202 NET338 NET340 NET415 FINAL_SRAM_G2
XI201 NET338 NET340 NET413 FINAL_SRAM_G2
XI200 NET338 NET340 NET409 FINAL_SRAM_G2
XI199 NET338 NET340 NET407 FINAL_SRAM_G2
XI198 NET338 NET340 NET405 FINAL_SRAM_G2
XI197 NET338 NET340 NET403 FINAL_SRAM_G2
XI196 NET338 NET340 NET401 FINAL_SRAM_G2
XI195 NET338 NET340 NET335 FINAL_SRAM_G2
XI194 NET338 NET340 NET411 FINAL_SRAM_G2
XI193 NET346 NET348 NET411 FINAL_SRAM_G2
XI192 NET346 NET348 NET335 FINAL_SRAM_G2
XI191 NET346 NET348 NET401 FINAL_SRAM_G2
XI190 NET346 NET348 NET403 FINAL_SRAM_G2
XI189 NET346 NET348 NET405 FINAL_SRAM_G2
XI188 NET346 NET348 NET407 FINAL_SRAM_G2
XI187 NET346 NET348 NET409 FINAL_SRAM_G2
XI186 NET346 NET348 NET413 FINAL_SRAM_G2
XI185 NET346 NET348 NET415 FINAL_SRAM_G2
XI184 NET346 NET348 NET417 FINAL_SRAM_G2
XI183 NET346 NET348 NET419 FINAL_SRAM_G2
XI182 NET346 NET348 NET421 FINAL_SRAM_G2
XI181 NET346 NET348 NET423 FINAL_SRAM_G2
XI180 NET346 NET348 NET425 FINAL_SRAM_G2
XI179 NET346 NET348 NET427 FINAL_SRAM_G2
XI178 NET346 NET348 NET429 FINAL_SRAM_G2
XI177 NET352 NET350 NET429 FINAL_SRAM_G2
XI176 NET352 NET350 NET427 FINAL_SRAM_G2
XI175 NET352 NET350 NET425 FINAL_SRAM_G2
XI174 NET352 NET350 NET423 FINAL_SRAM_G2
XI173 NET352 NET350 NET421 FINAL_SRAM_G2
XI172 NET352 NET350 NET419 FINAL_SRAM_G2
XI171 NET352 NET350 NET417 FINAL_SRAM_G2
XI170 NET352 NET350 NET415 FINAL_SRAM_G2
XI169 NET352 NET350 NET413 FINAL_SRAM_G2
XI168 NET352 NET350 NET409 FINAL_SRAM_G2
XI167 NET352 NET350 NET407 FINAL_SRAM_G2
XI166 NET352 NET350 NET405 FINAL_SRAM_G2
XI165 NET352 NET350 NET403 FINAL_SRAM_G2
XI164 NET352 NET350 NET401 FINAL_SRAM_G2
XI163 NET352 NET350 NET335 FINAL_SRAM_G2
XI162 NET352 NET350 NET411 FINAL_SRAM_G2
XI17 NET400 NET398 NET429 FINAL_SRAM_G2
XI16 NET400 NET398 NET427 FINAL_SRAM_G2
XI15 NET400 NET398 NET425 FINAL_SRAM_G2
XI14 NET400 NET398 NET423 FINAL_SRAM_G2
XI13 NET400 NET398 NET421 FINAL_SRAM_G2
XI12 NET400 NET398 NET419 FINAL_SRAM_G2
XI11 NET400 NET398 NET417 FINAL_SRAM_G2
XI10 NET400 NET398 NET415 FINAL_SRAM_G2
XI9 NET400 NET398 NET413 FINAL_SRAM_G2
XI8 NET400 NET398 NET409 FINAL_SRAM_G2
XI7 NET400 NET398 NET407 FINAL_SRAM_G2
XI6 NET400 NET398 NET405 FINAL_SRAM_G2
XI5 NET400 NET398 NET403 FINAL_SRAM_G2
XI4 NET400 NET398 NET401 FINAL_SRAM_G2
XI3 NET400 NET398 NET335 FINAL_SRAM_G2
XI2 NET400 NET398 NET411 FINAL_SRAM_G2
XI1 A0 A1 A2 A3 WL0 WL1 WL2 WL3 WL4 WL5 WL6 WL7 WL8 WL9 WL10 WL11 WL12 WL13
+WL14 WL15 FINAL_DECODER_G3

* FILE NAME: ECE471_LIB_FINAL_DECODER_SCHEMATIC.S.
* SUBCIRCUIT FOR CELL: FINAL_DECODER.
* GENERATED FOR: HSPICES.
* GENERATED ON MAR 19 17:52:07 2014.

* TERMINAL MAPPING: A0 = A0
*                   A1 = A1
*                   A2 = A2
*                   A3 = A3
*                   WL0 = WL0
*                   WL1 = WL1
*                   WL2 = WL2
*                   WL3 = WL3
*                   WL4 = WL4
*                   WL5 = WL5
*                   WL6 = WL6
*                   WL7 = WL7
*                   WL8 = WL8
*                   WL9 = WL9
*                   WL10 = WL10
*                   WL11 = WL11
*                   WL12 = WL12
*                   WL13 = WL13
*                   WL14 = WL14
*                   WL15 = WL15
.SUBCKT FINAL_DECODER_G3 A0 A1 A2 A3 WL0 WL1 WL2 WL3 WL4 WL5 WL6 WL7 WL8 WL9
+WL10 WL11 WL12 WL13 WL14 WL15
XI18 A2 2 SUB1
XI20 A0 4 SUB1
XI17 A3 1 SUB1
XI19 A1 3 SUB1
XI15 1 2 3 4 WL0 FINAL_AND4_G1
XI14 1 2 3 A0 WL1 FINAL_AND4_G1
XI13 1 2 A1 4 WL2 FINAL_AND4_G1
XI12 1 2 A1 A0 WL3 FINAL_AND4_G1
XI11 1 A2 3 4 WL4 FINAL_AND4_G1
XI10 1 A2 3 A0 WL5 FINAL_AND4_G1
XI9 1 A2 A1 4 WL6 FINAL_AND4_G1
XI8 1 A2 A1 A0 WL7 FINAL_AND4_G1
XI7 A3 A2 A1 A0 WL15 FINAL_AND4_G1
XI6 A3 A2 A1 4 WL14 FINAL_AND4_G1
XI5 A3 A2 3 A0 WL13 FINAL_AND4_G1
XI4 A3 A2 3 4 WL12 FINAL_AND4_G1
XI3 A3 2 A1 A0 WL11 FINAL_AND4_G1
XI2 A3 2 A1 4 WL10 FINAL_AND4_G1
XI1 A3 2 3 A0 WL9 FINAL_AND4_G1
XI0 A3 2 3 4 WL8 FINAL_AND4_G1

* END OF SUBCIRCUIT DEFINITION.
.ENDS FINAL_DECODER_G3
* FILE NAME: ECE471_LIB_FINAL_SRAM_SCHEMATIC.S.
* SUBCIRCUIT FOR CELL: FINAL_SRAM.
* GENERATED FOR: HSPICES.
* GENERATED ON MAR 19 17:52:07 2014.

* TERMINAL MAPPING: BL = BL
*                   BLB = BLB
*                   WL = WL
.SUBCKT FINAL_SRAM_G2 BL BLB WL
MN4 BL WL NET7 0  TSMC25DN  L=240E-9 W=360E-9 AD=216E-15 AS=216E-15 PD=1.92E-6
+PS=1.92E-6 M=1
MN2 BLB WL NET14 0  TSMC25DN  L=240E-9 W=360E-9 AD=216E-15 AS=216E-15
+PD=1.92E-6 PS=1.92E-6 M=1
MN1 NET7 NET14 0 0  TSMC25DN  L=240E-9 W=360E-9 AD=216E-15 AS=216E-15
+PD=1.92E-6 PS=1.92E-6 M=1
MN0 NET14 NET7 0 0  TSMC25DN  L=240E-9 W=360E-9 AD=216E-15 AS=216E-15
+PD=1.92E-6 PS=1.92E-6 M=1
MP1 NET7 NET14 VDD! VDD!  TSMC25DP  L=240E-9 W=360E-9 AD=216E-15 AS=216E-15
+PD=1.92E-6 PS=1.92E-6 M=1
MP0 NET14 NET7 VDD! VDD!  TSMC25DP  L=240E-9 W=360E-9 AD=216E-15 AS=216E-15
+PD=1.92E-6 PS=1.92E-6 M=1

* END OF SUBCIRCUIT DEFINITION.
.ENDS FINAL_SRAM_G2
* FILE NAME: ECE471_LIB_FINAL_SENSEAMP_SCHEMATIC.S.
* SUBCIRCUIT FOR CELL: FINAL_SENSEAMP.
* GENERATED FOR: HSPICES.
* GENERATED ON MAR 19 17:52:07 2014.

* TERMINAL MAPPING: EN = EN
*                   IN = IN
*                   INB = INB
*                   OUT = OUT
.SUBCKT SUB3 EN IN INB OUT
MN2 NET20 EN 0 0  TSMC25DN  L=240E-9 W=360E-9 AD=216E-15 AS=216E-15 PD=1.92E-6
+PS=1.92E-6 M=1
MN1 OUT INB NET20 0  TSMC25DN  L=240E-9 W=360E-9 AD=216E-15 AS=216E-15
+PD=1.92E-6 PS=1.92E-6 M=1
MN0 NET17 IN NET20 0  TSMC25DN  L=240E-9 W=360E-9 AD=216E-15 AS=216E-15
+PD=1.92E-6 PS=1.92E-6 M=1
MP1 OUT NET17 VDD! VDD!  TSMC25DP  L=240E-9 W=720E-9 AD=432E-15 AS=432E-15
+PD=2.64E-6 PS=2.64E-6 M=1
MP0 NET17 NET17 VDD! VDD!  TSMC25DP  L=240E-9 W=720E-9 AD=432E-15 AS=432E-15
+PD=2.64E-6 PS=2.64E-6 M=1

* END OF SUBCIRCUIT DEFINITION.
.ENDS SUB3
* FILE NAME: ECE471_LIB_FINAL_AND4_SCHEMATIC.S.
* SUBCIRCUIT FOR CELL: FINAL_AND4.
* GENERATED FOR: HSPICES.
* GENERATED ON MAR 19 17:52:07 2014.

* TERMINAL MAPPING: A = A
*                   B = B
*                   C = C
*                   D = D
*                   Y = Y
.SUBCKT FINAL_AND4_G1 A B C D Y
MN4 NET6 D 0 0  TSMC25DN  L=240E-9 W=2.88E-6 AD=1.728E-12 AS=1.728E-12
+PD=6.96E-6 PS=6.96E-6 M=1
MN0 Y NET42 0 0  TSMC25DN  L=240E-9 W=360E-9 AD=216E-15 AS=216E-15 PD=1.92E-6
+PS=1.92E-6 M=1
MN1 NET42 A NET14 0  TSMC25DN  L=240E-9 W=720E-9 AD=432E-15 AS=432E-15
+PD=2.64E-6 PS=2.64E-6 M=1
MN2 NET14 B NET10 0  TSMC25DN  L=240E-9 W=1.44E-6 AD=864E-15 AS=864E-15
+PD=4.08E-6 PS=4.08E-6 M=1
MN3 NET10 C NET6 0  TSMC25DN  L=240E-9 W=2.88E-6 AD=1.728E-12 AS=1.728E-12
+PD=6.96E-6 PS=6.96E-6 M=1
MP4 Y NET42 VDD! VDD!  TSMC25DP  L=240E-9 W=720E-9 AD=432E-15 AS=432E-15
+PD=2.64E-6 PS=2.64E-6 M=1
MP3 NET42 D VDD! VDD!  TSMC25DP  L=240E-9 W=720E-9 AD=432E-15 AS=432E-15
+PD=2.64E-6 PS=2.64E-6 M=1
MP2 NET42 C VDD! VDD!  TSMC25DP  L=240E-9 W=720E-9 AD=432E-15 AS=432E-15
+PD=2.64E-6 PS=2.64E-6 M=1
MP1 NET42 B VDD! VDD!  TSMC25DP  L=240E-9 W=720E-9 AD=432E-15 AS=432E-15
+PD=2.64E-6 PS=2.64E-6 M=1
MP0 NET42 A VDD! VDD!  TSMC25DP  L=240E-9 W=720E-9 AD=432E-15 AS=432E-15
+PD=2.64E-6 PS=2.64E-6 M=1

* END OF SUBCIRCUIT DEFINITION.
.ENDS FINAL_AND4_G1
* FILE NAME: ECE471_LIB_FINAL_PRECHARGE_SCHEMATIC.S.
* SUBCIRCUIT FOR CELL: FINAL_PRECHARGE.
* GENERATED FOR: HSPICES.
* GENERATED ON MAR 19 17:52:07 2014.

* TERMINAL MAPPING: EN = EN
*                   OUT = OUT
*                   OUTB = OUTB
.SUBCKT SUB2 EN OUT OUTB
MP1 OUTB EN VDD! VDD!  TSMC25DP  L=240E-9 W=360E-9 AD=216E-15 AS=216E-15
+PD=1.92E-6 PS=1.92E-6 M=1
MP0 OUT EN VDD! VDD!  TSMC25DP  L=240E-9 W=360E-9 AD=216E-15 AS=216E-15
+PD=1.92E-6 PS=1.92E-6 M=1

* END OF SUBCIRCUIT DEFINITION.
.ENDS SUB2
* FILE NAME: ECE471_LIB_FINAL_INVERTER_SCHEMATIC.S.
* SUBCIRCUIT FOR CELL: FINAL_INVERTER.
* GENERATED FOR: HSPICES.
* GENERATED ON MAR 19 17:52:07 2014.

* TERMINAL MAPPING: IN = IN
*                   OUT = OUT
.SUBCKT SUB1 IN OUT
MP0 OUT IN VDD! VDD!  TSMC25DP  L=240E-9 W=720E-9 AD=432E-15 AS=432E-15
+PD=2.64E-6 PS=2.64E-6 M=1
MN0 OUT IN 0 0  TSMC25DN  L=240E-9 W=360E-9 AD=216E-15 AS=216E-15 PD=1.92E-6
+PS=1.92E-6 M=1

* END OF SUBCIRCUIT DEFINITION.
.ENDS SUB1
* FILE NAME: ECE471_LIB_FINAL_TRISTATE_SCHEMATIC.S.
* SUBCIRCUIT FOR CELL: FINAL_TRISTATE.
* GENERATED FOR: HSPICES.
* GENERATED ON MAR 19 17:52:07 2014.

* TERMINAL MAPPING: A = A
*                   EN = EN
*                   Y = Y
.SUBCKT SUB4 A EN Y
XI0 EN 1 SUB1
MN2 NET6 A 0 0  TSMC25DN  L=240E-9 W=360E-9 AD=216E-15 AS=216E-15 PD=1.92E-6
+PS=1.92E-6 M=1
MN1 NET10 NET6 0 0  TSMC25DN  L=240E-9 W=720E-9 AD=432E-15 AS=432E-15
+PD=2.64E-6 PS=2.64E-6 M=1
MN0 Y EN NET10 0  TSMC25DN  L=240E-9 W=720E-9 AD=432E-15 AS=432E-15 PD=2.64E-6
+PS=2.64E-6 M=1
MP2 Y 1 NET21 VDD!  TSMC25DP  L=240E-9 W=1.44E-6 AD=864E-15 AS=864E-15
+PD=4.08E-6 PS=4.08E-6 M=1
MP1 NET21 NET6 VDD! VDD!  TSMC25DP  L=240E-9 W=1.44E-6 AD=864E-15 AS=864E-15
+PD=4.08E-6 PS=4.08E-6 M=1
MP0 NET6 A VDD! VDD!  TSMC25DP  L=240E-9 W=720E-9 AD=432E-15 AS=432E-15
+PD=2.64E-6 PS=2.64E-6 M=1

* END OF SUBCIRCUIT DEFINITION.
.ENDS SUB4
.END
