* # FILE NAME: /NFS/STAK/STUDENTS/B/BRANAUGJ/CADENCE/SIMULATION/LAB3_CKT/
* HSPICES/EXTRACTED/NETLIST/LAB3_CKT.C.RAW
* NETLIST OUTPUT FOR HSPICES.
* GENERATED ON JAN 31 16:03:42 2014

* FILE NAME: ECE471_LIB_LAB3_CKT_EXTRACTED.S.
* SUBCIRCUIT FOR CELL: LAB3_CKT.
* GENERATED FOR: HSPICES.
* GENERATED ON JAN 31 16:03:42 2014.

C4 VDD GND  80.856204E-15 M=1.0
C5 GND 3  89.013312E-15 M=1.0
M6 OUT 2 VDD VDD  TSMC25DP  L=239.99999143598E-9 W=959.999965743918E-9
+AD=576.000022418227E-15 AS=576.000022418227E-15 PD=2.15999989450211E-6
+PS=2.15999989450211E-6 M=1
M7 1 IN VDD VDD  TSMC25DP  L=239.99999143598E-9 W=959.999965743918E-9
+AD=576.000022418227E-15 AS=576.000022418227E-15 PD=2.15999989450211E-6
+PS=2.15999989450211E-6 M=1
M8 OUT 2 GND GND  TSMC25DN  L=239.99999143598E-9 W=479.999982871959E-9
+AD=288.000011209114E-15 AS=288.000011209114E-15 PD=1.67999996847357E-6
+PS=1.67999996847357E-6 M=1
M9 1 IN GND GND  TSMC25DN  L=239.99999143598E-9 W=479.999982871959E-9
+AD=288.000011209114E-15 AS=288.000011209114E-15 PD=1.67999996847357E-6
+PS=1.67999996847357E-6 M=1
