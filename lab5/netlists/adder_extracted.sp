* # FILE NAME: /NFS/STAK/STUDENTS/B/BRANAUGJ/CADENCE/SIMULATION/LAB5_ADDER/
* HSPICES/EXTRACTED/NETLIST/LAB5_ADDER.C.RAW
* NETLIST OUTPUT FOR HSPICES.
* GENERATED ON FEB 21 17:20:53 2014

* FILE NAME: ECE471_LIB_LAB5_ADDER_EXTRACTED.S.
* SUBCIRCUIT FOR CELL: LAB5_ADDER.
* GENERATED FOR: HSPICES.
* GENERATED ON FEB 21 17:20:53 2014.

C20 0 5  3.9299928E-15 M=1.0
C21 0 2  6.0693096E-15 M=1.0
C22 S 0  2.3193696E-15 M=1.0
C23 CO 0  2.7899616E-15 M=1.0
C24 CI 0  5.3949552E-15 M=1.0
C25 B 0  8.7915384E-15 M=1.0
C26 A 0  9.2718336E-15 M=1.0
C27 VDD! 0  14.0550048E-15 M=1.0
C28 0 5  4.320432E-15 M=1.0
C29 0 2  3.019572E-15 M=1.0
C30 S 0  2.554416E-15 M=1.0
C31 CO 0  2.499228E-15 M=1.0
M32 5 2 17 VDD!  TSMC25DP  L=239.99999143598E-9 W=1.91999993148784E-6
+AD=1.15200004483645E-12 AS=1.15200004483645E-12 PD=3.11999997393286E-6
+PS=3.11999997393286E-6 M=1
M33 17 CI VDD! VDD!  TSMC25DP  L=239.99999143598E-9 W=1.91999993148784E-6
+AD=1.15200004483645E-12 AS=1.15200004483645E-12 PD=3.11999997393286E-6
+PS=3.11999997393286E-6 M=1
M34 17 B VDD! VDD!  TSMC25DP  L=239.99999143598E-9 W=1.91999993148784E-6
+AD=1.15200004483645E-12 AS=1.15200004483645E-12 PD=3.11999997393286E-6
+PS=3.11999997393286E-6 M=1
M35 17 A VDD! VDD!  TSMC25DP  L=239.99999143598E-9 W=1.91999993148784E-6
+AD=1.15200004483645E-12 AS=1.15200004483645E-12 PD=3.11999997393286E-6
+PS=3.11999997393286E-6 M=1
M36 2 A 16 VDD!  TSMC25DP  L=239.99999143598E-9 W=1.91999993148784E-6
+AD=1.15200004483645E-12 AS=1.15200004483645E-12 PD=3.11999997393286E-6
+PS=3.11999997393286E-6 M=1
M37 16 B VDD! VDD!  TSMC25DP  L=239.99999143598E-9 W=1.91999993148784E-6
+AD=1.15200004483645E-12 AS=1.15200004483645E-12 PD=3.11999997393286E-6
+PS=3.11999997393286E-6 M=1
M38 5 CI 19 VDD!  TSMC25DP  L=239.99999143598E-9 W=2.88000001091859E-6
+AD=1.72800001304457E-12 AS=1.72800001304457E-12 PD=4.08000005336362E-6
+PS=4.08000005336362E-6 M=1
M39 19 B 18 VDD!  TSMC25DP  L=239.99999143598E-9 W=2.88000001091859E-6
+AD=1.72800001304457E-12 AS=1.72800001304457E-12 PD=4.08000005336362E-6
+PS=4.08000005336362E-6 M=1
M40 18 A VDD! VDD!  TSMC25DP  L=239.99999143598E-9 W=2.88000001091859E-6
+AD=1.72800001304457E-12 AS=1.72800001304457E-12 PD=4.08000005336362E-6
+PS=4.08000005336362E-6 M=1
M41 S 5 VDD! VDD!  TSMC25DP  L=239.99999143598E-9 W=5.76000002183719E-6
+AD=3.45600002608915E-12 AS=3.45600002608915E-12 PD=6.96000006428221E-6
+PS=6.96000006428221E-6 M=1
M42 CO 2 VDD! VDD!  TSMC25DP  L=239.99999143598E-9 W=5.76000002183719E-6
+AD=3.45600002608915E-12 AS=3.45600002608915E-12 PD=6.96000006428221E-6
+PS=6.96000006428221E-6 M=1
M43 2 CI 15 VDD!  TSMC25DP  L=239.99999143598E-9 W=5.76000002183719E-6
+AD=3.45600002608915E-12 AS=3.45600002608915E-12 PD=6.96000006428221E-6
+PS=6.96000006428221E-6 M=1
M44 15 B VDD! VDD!  TSMC25DP  L=239.99999143598E-9 W=5.76000002183719E-6
+AD=3.45600002608915E-12 AS=3.45600002608915E-12 PD=6.96000006428221E-6
+PS=6.96000006428221E-6 M=1
M45 15 A VDD! VDD!  TSMC25DP  L=239.99999143598E-9 W=5.76000002183719E-6
+AD=3.45600002608915E-12 AS=3.45600002608915E-12 PD=6.96000006428221E-6
+PS=6.96000006428221E-6 M=1
M46 5 2 4 0  TSMC25DN  L=239.99999143598E-9 W=959.999965743918E-9
+AD=576.000022418227E-15 AS=576.000022418227E-15 PD=2.15999989450211E-6
+PS=2.15999989450211E-6 M=1
M47 4 CI 0 0  TSMC25DN  L=239.99999143598E-9 W=959.999965743918E-9
+AD=576.000022418227E-15 AS=576.000022418227E-15 PD=2.15999989450211E-6
+PS=2.15999989450211E-6 M=1
M48 4 B 0 0  TSMC25DN  L=239.99999143598E-9 W=959.999965743918E-9
+AD=576.000022418227E-15 AS=576.000022418227E-15 PD=2.15999989450211E-6
+PS=2.15999989450211E-6 M=1
M49 4 A 0 0  TSMC25DN  L=239.99999143598E-9 W=959.999965743918E-9
+AD=576.000022418227E-15 AS=576.000022418227E-15 PD=2.15999989450211E-6
+PS=2.15999989450211E-6 M=1
M50 2 A 3 0  TSMC25DN  L=239.99999143598E-9 W=959.999965743918E-9
+AD=576.000022418227E-15 AS=576.000022418227E-15 PD=2.15999989450211E-6
+PS=2.15999989450211E-6 M=1
M51 3 B 0 0  TSMC25DN  L=239.99999143598E-9 W=959.999965743918E-9
+AD=576.000022418227E-15 AS=576.000022418227E-15 PD=2.15999989450211E-6
+PS=2.15999989450211E-6 M=1
M52 5 CI 7 0  TSMC25DN  L=239.99999143598E-9 W=1.4400000054593E-6
+AD=864.000006522286E-15 AS=864.000006522286E-15 PD=2.64000004790432E-6
+PS=2.64000004790432E-6 M=1
M53 7 A 6 0  TSMC25DN  L=239.99999143598E-9 W=1.4400000054593E-6
+AD=864.000006522286E-15 AS=864.000006522286E-15 PD=2.64000004790432E-6
+PS=2.64000004790432E-6 M=1
M54 6 B 0 0  TSMC25DN  L=239.99999143598E-9 W=1.4400000054593E-6
+AD=864.000006522286E-15 AS=864.000006522286E-15 PD=2.64000004790432E-6
+PS=2.64000004790432E-6 M=1
M55 S 5 0 0  TSMC25DN  L=239.99999143598E-9 W=2.88000001091859E-6
+AD=1.72800001304457E-12 AS=1.72800001304457E-12 PD=4.08000005336362E-6
+PS=4.08000005336362E-6 M=1
M56 CO 2 0 0  TSMC25DN  L=239.99999143598E-9 W=2.88000001091859E-6
+AD=1.72800001304457E-12 AS=1.72800001304457E-12 PD=4.08000005336362E-6
+PS=4.08000005336362E-6 M=1
M57 2 CI 1 0  TSMC25DN  L=239.99999143598E-9 W=2.88000001091859E-6
+AD=1.72800001304457E-12 AS=1.72800001304457E-12 PD=4.08000005336362E-6
+PS=4.08000005336362E-6 M=1
M58 1 B 0 0  TSMC25DN  L=239.99999143598E-9 W=2.88000001091859E-6
+AD=1.72800001304457E-12 AS=1.72800001304457E-12 PD=4.08000005336362E-6
+PS=4.08000005336362E-6 M=1
M59 1 A 0 0  TSMC25DN  L=239.99999143598E-9 W=2.88000001091859E-6
+AD=1.72800001304457E-12 AS=1.72800001304457E-12 PD=4.08000005336362E-6
+PS=4.08000005336362E-6 M=1
